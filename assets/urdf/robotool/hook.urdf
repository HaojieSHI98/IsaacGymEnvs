Commit message: add robotool

File: assets/urdf/robotool/hook.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- removed link ball
- added link hook; collision mesh filename=meshes/hook.obj; visual mesh filename=meshes/hook.obj
